SUMMARY = "Phone platform prototype: TUI shell, media, keystore, audio and push services, apps"
DESCRIPTION = "phone-shell (phone.Ui renderer, broker, trusted UI), phone-mediad, \
phone-keystored, phone-audiod, phone-pushd (+ the simulated gateway phone-pushgw) and the apps (phone, messages, clock, calculator, music, \
chat with video calls, wallet with trusted payments, settings)."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://src/${GO_IMPORT}/LICENSE;md5=${PHONE_FW_LICENSE_MD5}"
PHONE_FW_LICENSE_MD5 = "89aea4e17d99a7cacdbeed46a0096b10"

# The module at ${S}/src/${GO_IMPORT}: the tarball `make yocto-src` packs
# from the working tree (as kario/, without vendor/), or the commit
# (phone-src.bbclass). Its dependencies are in -go-mods.inc.
SRC_URI = "${@phone_src(d, 'file://phone-fw-src.tar.gz;subdir=${BP}/src/github.com/kario-os', dest='${BP}/src/${GO_IMPORT}')} \
           file://phone-mediad.service \
           file://phone-mediad.socket \
           file://phone-keystored.socket \
           file://phone-audiod.socket \
           file://phone-imed.socket \
           file://phone-imed.service \
           file://phone-fdstore-check.service \
           file://phone-keystored.service \
           file://phone-audiod.service \
           file://phone-pushd.service \
           file://phone-nfcd.service \
           file://phone-displayd.service \
           file://phone-smsd.service \
           file://phone-wipe.service \
           file://phone-clock.service \
           file://phone-pushgw.service \
           file://phone-chatsrv.service \
           file://phone-storesrv.service \
           file://phone-display.service \
           file://phone-gui-console-generator \
           file://phone-gui-console.service \
           file://gui-console \
           file://phone-selftest.service \
           file://selftest-boot.sh \
           file://selftest-heartbeat.sh \
           file://console-file \
           file://module-check.sh \
           file://phone-bench.service \
           file://bench-boot.sh \
           file://phone-stress.service \
           file://stress-boot.sh \
           file://stress.script \
           file://phone-soak.service \
           file://soak-boot.sh \
           file://phone-tmpfiles.conf \
           file://phone-profile.sh \
           file://phone-charger-generator \
           file://phone-charger.target \
           file://phone-charger.service \
           file://phone-charger-radios.service \
           file://phone-charger-test.service \
           file://charger-test.sh \
          "

GO_IMPORT = "github.com/kario-os/kario"
GO_INSTALL = "${GO_IMPORT}/cmd/... ${GO_IMPORT}/apps/... ${GO_IMPORT}/cts/... ${GO_IMPORT}/examples/..."

inherit go-mod systemd phone-src

# Generated by tools/gomodinc.py (`make gomods`) from go.mod and go.sum.
require ${BPN}-go-mods.inc
require ${BPN}-licenses.inc

# Every binary carries the part of the standard library it uses. With
# aarch64's default (GO_DYNLINK: all link libstd.so) each process relocates
# libstd.so's 6 MB of pointer tables into private pages, about 6-7 MB per
# process; a static PIE relocates only its own 0.25 MB. No cgo either: none
# of the code needs it, and the internal linker makes the static PIE.
GO_DYNLINK:aarch64 = ""
GO_DYNLINK:arm = ""
GO_DYNLINK:x86-64 = ""
export CGO_ENABLED = "0"

# A release's version (PHONE_VERSION, set by kario-internal's release
# configuration) in Settings › About, the compatibility report and the health record.
PHONE_VERSION ??= ""
GO_EXTRA_LDFLAGS:append = "${@' -X ${GO_IMPORT}/shell.SystemVersion=' + d.getVar('PHONE_VERSION') if d.getVar('PHONE_VERSION') else ''}"

# Offline, reproducible: dependencies come from the module cache bitbake
# filled (gomod://, checked against go.sum as well); go.mod is not touched.
export GOFLAGS = "-mod=readonly"
export GOPROXY = "off"
export GOTOOLCHAIN = "local"

# The input method's dictionary is compiled at build time: phone-imedict is
# built a second time for the build host and run there; so is kario, which
# compiles the TypeScript sample (kario-jsrt, its runtime, has its own
# recipe). ${GO} is a wrapper that pins GOARCH to the target, so this calls
# the toolchain's go itself.
do_compile:append() {
    cd ${S}/src/${GO_IMPORT}
    GOOS=${BUILD_GOOS} GOARCH=${BUILD_GOARCH} CGO_ENABLED=0 ${STAGING_LIBDIR_NATIVE}/${TARGET_SYS}/go/bin/go build -trimpath -o ${B}/host/phone-imedict ./cmd/phone-imedict
    GOOS=${BUILD_GOOS} GOARCH=${BUILD_GOARCH} CGO_ENABLED=0 ${STAGING_LIBDIR_NATIVE}/${TARGET_SYS}/go/bin/go build -trimpath -o ${B}/host/kario ./cmd/kario
    ${B}/host/phone-imedict -o ${B}/ime.dict
    # The native module of the sample examples/imgproc, for the target,
    # with the target's compiler; stage.sh puts it in the sample's package
    # source (NATIVE_DIR), which the selftest installs.
    if [ -n "${KARIO_NATIVE_ARCH}" ]; then
        mkdir -p ${B}/native/${KARIO_NATIVE_ARCH}
        ${CC} ${CFLAGS} ${LDFLAGS} -shared -fPIC -I${S}/src/${GO_IMPORT}/sdk/c/include \
            -o ${B}/native/${KARIO_NATIVE_ARCH}/imgproc.so ${S}/src/${GO_IMPORT}/examples/imgproc/native/imgproc.c
    fi
}

# Native modules' architecture names (jsrt.Arches): lib/<arch>/ in a package.
KARIO_NATIVE_ARCH = "${@ {'aarch64': 'arm64', 'x86_64': 'x86_64'}.get(d.getVar('TARGET_ARCH'), '')}"

DEPENDS += "kario-jsrt-native"

do_install() {
    IME_DICT=${B}/ime.dict KARIO_CLI=${B}/host/kario KARIO_JSRT_HOST=${STAGING_LIBDIR_NATIVE}/phone/bin/kario-jsrt NATIVE_DIR=${B}/native sh ${S}/src/${GO_IMPORT}/scripts/stage.sh ${B}/${GO_BUILD_BINDIR} ${D}${prefix}
    # kario is a static Go program: pseudo cannot see the files it writes,
    # which keep the build user as owner unless chown (under pseudo) says.
    chown -R root:root ${D}${datadir}/phone/apps/hello-ts ${D}${datadir}/phone/apps/calc ${D}${datadir}/phone/apps/calendar
    if [ -d ${D}${datadir}/phone/examples/imgproc ]; then chown -R root:root ${D}${datadir}/phone/examples/imgproc; fi
    if [ -d ${D}${datadir}/phone/examples/karioui-notes ]; then chown -R root:root ${D}${datadir}/phone/examples/karioui-notes; fi
    if [ -d ${D}${datadir}/phone/examples/netcheck ]; then chown -R root:root ${D}${datadir}/phone/examples/netcheck; fi
    if [ -d ${D}${datadir}/phone/examples/keepalive-ts ]; then chown -R root:root ${D}${datadir}/phone/examples/keepalive-ts; fi

    install -d ${D}${systemd_system_unitdir} ${D}${libexecdir}/phone ${D}${nonarch_libdir}/tmpfiles.d ${D}${sysconfdir}/profile.d
    install -m 0644 ${UNPACKDIR}/phone-mediad.service ${UNPACKDIR}/phone-keystored.service ${UNPACKDIR}/phone-audiod.service \
        ${UNPACKDIR}/phone-pushd.service ${UNPACKDIR}/phone-pushgw.service ${UNPACKDIR}/phone-chatsrv.service ${UNPACKDIR}/phone-storesrv.service ${UNPACKDIR}/phone-display.service \
        ${UNPACKDIR}/phone-selftest.service ${UNPACKDIR}/phone-bench.service ${UNPACKDIR}/phone-stress.service ${UNPACKDIR}/phone-soak.service \
        ${UNPACKDIR}/phone-mediad.socket ${UNPACKDIR}/phone-keystored.socket ${UNPACKDIR}/phone-audiod.socket \
        ${UNPACKDIR}/phone-imed.socket ${UNPACKDIR}/phone-imed.service ${UNPACKDIR}/phone-fdstore-check.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-nfcd.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-displayd.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-smsd.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-wipe.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-clock.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/phone-charger.target ${UNPACKDIR}/phone-charger.service ${UNPACKDIR}/phone-charger-radios.service \
        ${UNPACKDIR}/phone-charger-test.service ${D}${systemd_system_unitdir}/
    install -D -m 0755 ${UNPACKDIR}/phone-charger-generator ${D}${systemd_unitdir}/system-generators/phone-charger-generator
    install -m 0644 ${UNPACKDIR}/phone-gui-console.service ${D}${systemd_system_unitdir}/
    install -m 0755 ${UNPACKDIR}/phone-gui-console-generator ${D}${systemd_unitdir}/system-generators/
    install -m 0755 ${UNPACKDIR}/selftest-boot.sh ${UNPACKDIR}/selftest-heartbeat.sh ${UNPACKDIR}/bench-boot.sh ${UNPACKDIR}/stress-boot.sh ${UNPACKDIR}/soak-boot.sh \
        ${UNPACKDIR}/module-check.sh ${UNPACKDIR}/charger-test.sh ${UNPACKDIR}/console-file ${UNPACKDIR}/gui-console ${D}${libexecdir}/phone/
    install -d ${D}${datadir}/phone
    install -m 0644 ${UNPACKDIR}/stress.script ${D}${datadir}/phone/
    install -m 0644 ${UNPACKDIR}/phone-tmpfiles.conf ${D}${nonarch_libdir}/tmpfiles.d/phone.conf
    install -m 0644 ${UNPACKDIR}/phone-profile.sh ${D}${sysconfdir}/profile.d/phone.sh
}

# keystored, mediad, audiod and imed start on their sockets' first connection.
SYSTEMD_SERVICE:${PN} = "phone-mediad.socket phone-keystored.socket phone-audiod.socket phone-imed.socket phone-pushd.service phone-pushgw.service phone-chatsrv.service phone-storesrv.service phone-selftest.service phone-bench.service phone-stress.service phone-display.service"
SYSTEMD_SERVICE:${PN} += "phone-nfcd.service"
SYSTEMD_SERVICE:${PN} += "phone-displayd.service"
SYSTEMD_SERVICE:${PN} += "phone-soak.service"
SYSTEMD_SERVICE:${PN} += "phone-smsd.service"
# A factory reset's wipe where the data shares the root file system
# (docs/31 §11); the script is phone-wipe's, which the initramfs uses too.
SYSTEMD_SERVICE:${PN} += "phone-wipe.service"
# The clock from a read-only RTC and the offset the Shell keeps, early at
# boot (hal/rtc); a settable RTC it only writes at shutdown, while NTP
# keeps the clock.
SYSTEMD_SERVICE:${PN} += "phone-clock.service"
RDEPENDS:${PN} += "phone-wipe"

# phone-audiod plays through aplay when the kernel has a sound card.
RDEPENDS:${PN} += "alsa-utils-aplay"

# The calculator and the calendar are TypeScript apps, and the mini-program host starts a
# process of kario-jsrt (beside it in lib/phone/bin) for each mini-program.
RDEPENDS:${PN} += "kario-jsrt"

# phone-mediad decodes videos with ffmpeg and ffprobe (royalty-free formats,
# kas/phone-qemuarm64.yml); without them the gallery shows videos it cannot
# play.
RDEPENDS:${PN} += "ffmpeg"

# Per-app traffic and Wi-Fi only: the rules set and match conntrack marks;
# the kernel loads nft_ct (and conntrack with it) when they are added.
RDEPENDS:${PN} += "kernel-module-nft-ct"
# The personal hotspot's NAT: the kernel loads these when the Shell adds
# its masquerading chain.
RDEPENDS:${PN} += "kernel-module-nft-masq kernel-module-nft-chain-nat kernel-module-nf-nat"

FILES:${PN} += "${libdir}/phone ${datadir}/phone ${libexecdir}/phone ${nonarch_libdir}/tmpfiles.d"
# Not enabled: the boot selftest starts it.
FILES:${PN} += "${systemd_system_unitdir}/phone-fdstore-check.service"
# Charger mode (28-battery.md §10): the generator makes phone-charger.target
# the default target when the bootloader says androidboot.mode=charger;
# the target pulls the rest.
FILES:${PN} += "${systemd_unitdir}/system-generators/phone-charger-generator ${systemd_system_unitdir}/phone-charger.target \
                ${systemd_system_unitdir}/phone-charger.service ${systemd_system_unitdir}/phone-charger-radios.service \
                ${systemd_system_unitdir}/phone-charger-test.service"
# The GUI drive's console (yocto/qemu-gui.sh): the generator pulls the
# service in with phone.gui-console on the kernel command line.
FILES:${PN} += "${systemd_unitdir}/system-generators/phone-gui-console-generator ${systemd_system_unitdir}/phone-gui-console.service"
FILES:${PN}-dev = ""
RDEPENDS:${PN}-dev = ""

# The hello-py sample is skipped at runtime when python3 is absent.
INSANE_SKIP:${PN} += "file-rdeps"
# The native sample's library is package data under share/phone/examples
# (signed into a package at run time), not a library of the image.
INSANE_SKIP:${PN} += "libdir"
