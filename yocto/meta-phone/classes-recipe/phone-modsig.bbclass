# Every kernel module in the image must load under the kernel's lockdown
# (phone-lockdown.cfg): in the directory of the deployed kernel's release,
# signed with the build directory's key (phone-kernel.inc), whose
# certificate that kernel carries. The image takes its modules from
# packages and the boot image takes the kernel from the kernel's deploy
# step, and the shared sstate can serve the two from different builds:
# the 6T's first whole-phone image paired a kernel with modules signed by
# another build's autogenerated key, and the phone refused every one of
# them. files/phone-modsig-check.py reads the kernel and the modules.
#
#   inherit phone-modsig

PHONE_OTA_KEYS ??= "${TOPDIR}/../ota-keys"
PHONE_MODULE_KEY ??= "${PHONE_OTA_KEYS}/kernel-modules.pem"
PHONE_MODSIG_CHECK = "${@bb.utils.which(d.getVar('BBPATH'), 'files/phone-modsig-check.py')}"
# What is flashed or booted besides the kernel image: phone-bootimg's boot
# image, where the machine has one.
PHONE_MODSIG_KERNELS ??= "${KERNEL_IMAGETYPE} boot-${MACHINE}.img"

ERROR_QA:append = " modules-signed"
do_image_qa[depends] += "virtual/kernel:do_deploy"
do_image_qa[file-checksums] += "${PHONE_MODSIG_CHECK}:True ${PHONE_MODULE_KEY}:True"
do_image_qa[vardeps] += "PHONE_MODSIG_KERNELS"
IMAGE_QA_COMMANDS += "phone_modsig_check"

python phone_modsig_check() {
    import os, subprocess
    deploy = d.getVar('DEPLOY_DIR_IMAGE')
    kernels = [os.path.join(deploy, k) for k in d.getVar('PHONE_MODSIG_KERNELS').split()
               if os.path.exists(os.path.join(deploy, k))]
    if not kernels:
        oe.qa.handle_error("modules-signed", "no kernel in %s to check the modules against (%s)"
                           % (deploy, d.getVar('PHONE_MODSIG_KERNELS')), d)
        return
    args = ['python3', d.getVar('PHONE_MODSIG_CHECK')]
    for k in kernels:
        args += ['--kernel', k]
    args += ['--cert', d.getVar('PHONE_MODULE_KEY'),
             d.getVar('IMAGE_ROOTFS') + d.getVar('nonarch_base_libdir') + '/modules']
    r = subprocess.run(args, stdout=subprocess.PIPE, stderr=subprocess.STDOUT, text=True)
    bb.note(r.stdout)
    if r.returncode != 0:
        oe.qa.handle_error("modules-signed", "the kernel would refuse modules of this image:\n" + r.stdout, d)
}
